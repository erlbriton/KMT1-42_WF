# IAR project KMT1-42.ewp, settings and files
configuration blank (ARM)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device\ST\STM32F4xx\Include; ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4xx_StdPeriph_Driver; ..\Utilities; ..\DExS_M4CPU; ..\User; ..\EFI_CPU; ..\rectifier
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: KMT1-42.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration STM32F407IGT6 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device\ST\STM32F4xx\Include; ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4xx_StdPeriph_Driver; ..\Utilities; ..\DExS_M4CPU; ..\User; ..\rectifier
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PHTTE.CPU.hex
configuration STM32F405RG (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device\ST\STM32F4xx\Include; ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4xx_StdPeriph_Driver; ..\Utilities; ..\EFI_CPU; ..\User; ..\rectifier
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EFI_CPU_test.hex
  group CMSIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EFI_CPU
    ../EFI_CPU/: DIO.c fram.c init.c rtc.c uart1toRS485.c uart2toRS485.c
  group EWARMv6
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group rectifier
    ../rectifier/: IPCS_STM32F4.c
  group StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../User/: AIO.c CDdata.c EFI_CPU.c flashdata.c main.cpp modbus.c ramdata.c stm32f4xx_it.c
  group Utilities
    ../Utilities/: crc16.c id.c memutil.c
